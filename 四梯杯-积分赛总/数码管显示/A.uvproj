# Keil uVision project A.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: A +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\library\device;.\library\system
  group main
    ./: STARTUP.A51 main.c
  group device
    ./library/device/: kbd.c smg.c p2p0.c
  group system
    ./library/system/: Timer.c
