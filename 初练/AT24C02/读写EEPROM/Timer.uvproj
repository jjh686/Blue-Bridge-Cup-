# Keil uVision project Timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC-ISP +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\System;.\Library\Device
  group Main
    ./: STARTUP.A51 main.c
  group System
    ./Library/System/: Delay.c Timer.c
  group Device
    ./Library/Device/: Device.c SMG.c BTN.c KBD.c onewire.c iic.c
