# Keil uVision project 2026_4_10.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 17492442 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\library\deivce;.\library\system
  group main
    ./: STARTUP.A51 main.c
  group system
    ./library/system/: timer.c uart.c
  group device
    ./library/deivce/: p2p0.c smg.c kbd.c iic.c sonic.c ne555.c
