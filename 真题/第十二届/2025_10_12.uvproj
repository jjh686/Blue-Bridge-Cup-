# Keil uVision project 2025_10_12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2025_10_12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\library\device;.\library\system
  group main
    ./: STARTUP.A51 main.c
  group system
    ./library/system/: Timer.c Delay.c
  group device
    ./library/device/: iic.c onewire.c smg.c P2P0.c kbd.c
