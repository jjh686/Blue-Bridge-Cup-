# Keil uVision project 2026_3_14.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2026_3_14 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\library\device;.\library\system
  group main
    ./: STARTUP.A51 main.c
  group system
    ./library/system/: timer.c
  group device
    ./library/device/: p2p0.c smg.c kbd.c onewire.c iic.c sonic.c
