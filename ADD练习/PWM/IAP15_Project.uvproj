# Keil uVision project IAP15_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IAP15_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\System;.\Library\Device
  link misc: REMOVEUNUSED
  group Main
    ./: STARTUP.A51 main.c
  group System
    ./Library/System/: Uart.c Delay.c Timer.c
  group Device
    ./Library/Device/: Device.c SMG.c BTN.c KBD.c onewire.c iic.c ds1302.c NE555.c Sonic.c
